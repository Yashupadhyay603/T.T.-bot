Commit message: corrected inertial and collision tags
#collision bug fixed

File: week 1/puck(1).urdf (robot description, URDF)
Before this commit: robot puck, 1 links, 0 joints
Links:
- link base: mass 0.048 -> 0.3
